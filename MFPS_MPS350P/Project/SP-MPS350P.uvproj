# Keil uVision project SP-MPS350P.uvproj, settings and files
target MultiFunPower (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: SP_MPS_350PA_HW1.12_SW001_20250514 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\Inc;..\Core\Inc;..\Driver;..\Emembed\Inc;..\SYSTEM\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Driver
    ../Driver/: STC8H.H
  group SYSTEM
    ../SYSTEM/Src/: delay.c
  group Core
    ../Core/Src/: adc.c gpio.c main.c pwm.c tim.c uart.c eeprom.c
  group BSP
    ../BSP/Src/: ntc.c power_crl.c cc6903.c communication.c eeprom_crl.c dht11.c
  group Emembed
    ../Emembed/Src/: modbus_rtu.c common.c
